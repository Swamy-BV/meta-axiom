FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://axiom.cfg"
