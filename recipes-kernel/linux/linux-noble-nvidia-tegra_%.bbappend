FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://tracing.cfg"
